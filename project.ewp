# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread\components\net\sal_socket\include\socket\sys_socket; rt-thread\include; rt-thread\components\net\sal_socket\include\dfs_net\sys_select; rt-thread\components\net\sal_socket\include\dfs_net; packages\webnet-v2.0.1\inc; rt-thread\components\net\lwip-2.0.2\src; rt-thread\components\finsh; board\CubeMX_Config\Src\generated\images\include; board\CubeMX_Config\Src; rt-thread\components\net\lwip-2.0.2\src\include; board\CubeMX_Config\Inc; libraries\HAL_Drivers\config; libraries\HAL_Drivers; rt-thread\components\net\lwip-2.0.2\src\include\ipv4; libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; rt-thread\libcpu\arm\common; rt-thread\components\net\lwip-2.0.2\src\arch\include; .; rt-thread\components\drivers\include; board; packages\netutils-v1.1.0\ntp; packages\netutils-v1.1.0\telnet; libraries\HAL_Drivers\drv_flash; rt-thread\components\libc\compilers\dlib; rt-thread\components\net\netdev\include; libraries\STM32F4xx_HAL\CMSIS\Include; packages\netutils-v1.1.0\tftp; board\CubeMX_Config\Src\gui\include; board\ports; rt-thread\libcpu\arm\cortex-m4; applications; board\CubeMX_Config\Middlewares\ST\touchgfx\framework\include; packages\cJSON-v1.0.2; packages\network_samples-v0.3.0; rt-thread\components\dfs\filesystems\devfs; rt-thread\components\net\lwip-2.0.2\src\include\netif; libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; rt-thread\components\net\sal_socket\include; rt-thread\components\drivers\spi\sfud\inc; board\CubeMX_Config\Src\generated\fonts\include; rt-thread\components\dfs\include; packages\webclient-v2.1.2\inc; rt-thread\components\dfs\filesystems\elmfat; packages\fal-latest\inc; board\CubeMX_Config\Src\generated\gui_generated\include; rt-thread\components\libc\compilers\common; rt-thread\components\net\sal_socket\impl; board\CubeMX_Config\Src\generated\texts\include; rt-thread\components\drivers\spi; rt-thread\components\net\sal_socket\include\socket
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Applications
    applications/: main.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group dlib
    rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c
  group Drivers
    board/: board.c
    libraries/HAL_Drivers/: drv_common.c drv_eth.c drv_gpio.c drv_lcd_rgb.c drv_ltdc.c drv_sdram.c drv_soft_spi.c drv_spi.c drv_touch.c drv_usart.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
    board/ports/: phy_reset.c spi_flash_init.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-latest/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    rt-thread/components/finsh/: cmd.c msh.c msh_file.c shell.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group NetUtils
    packages/netutils-v1.1.0/ntp/: ntp.c
    packages/netutils-v1.1.0/telnet/: telnet.c
    packages/netutils-v1.1.0/tftp/: tftp_port.c tftp_server.c
  group network-samples
    packages/network_samples-v0.3.0/: httpclient_sample.c tcpclient_sample.c tcpclient_select_sample.c tcpserver_sample.c udpclient_sample.c udpserver_sample.c
  group SAL
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
  group STM32_HAL
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ltdc.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group TouchGFX_app
    board/CubeMX_Config/Src/: app_touchgfx.c OSWrappers-rtt.cpp STM32DMA.cpp STM32TouchController.cpp touchgfx_sample.c TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp TouchGFXGPIO.cpp TouchGFXHAL.cpp
    board/CubeMX_Config/Middlewares/ST/touchgfx/lib/core/cortex_m4f/IAR8.x/: touchgfx_core.a
  group TouchGFX_generated
    board/CubeMX_Config/Src/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_DENGB_TTF_20_4bpp_0.cpp Font_DENGB_TTF_20_4bpp_10.cpp Font_DENGB_TTF_20_4bpp_12.cpp Font_DENGB_TTF_20_4bpp_14.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_DENGB_TTF_20_4bpp.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_DENGB_TTF_20_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp
    board/CubeMX_Config/Src/generated/images/src/: BitmapDatabase.cpp image_lightbulb_1.cpp image_lightbulb_2.cpp image_shou.cpp image_xuanzhong.cpp
    board/CubeMX_Config/Src/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    board/CubeMX_Config/Src/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
    board/CubeMX_Config/Src/generated/gui_generated/src/screen1_screen/: screen1ViewBase.cpp
    board/CubeMX_Config/Src/generated/gui_generated/src/screen2_screen/: Screen2ViewBase.cpp
    board/CubeMX_Config/Src/generated/gui_generated/src/screen3_screen/: Screen3ViewBase.cpp
  group TouchGFX_gui
    board/CubeMX_Config/Src/gui/src/common/: FrontendApplication.cpp
    board/CubeMX_Config/Src/gui/src/model/: Model.cpp
    board/CubeMX_Config/Src/gui/src/screen1_screen/: screen1Presenter.cpp screen1View.cpp
    board/CubeMX_Config/Src/gui/src/screen2_screen/: Screen2Presenter.cpp Screen2View.cpp
    board/CubeMX_Config/Src/gui/src/screen3_screen/: Screen3Presenter.cpp Screen3View.cpp
  group TouchGFX_resource
    board/CubeMX_Config/Src/generated/images/src/__designer/: image_Blue_Buttons_Round_Edge_small.cpp image_Blue_Buttons_Round_Edge_small_pressed.cpp
  group WebClient
    packages/webclient-v2.1.2/src/: webclient.c webclient_file.c
    packages/webclient-v2.1.2/samples/: webclient_get_sample.c webclient_post_sample.c
  group WebNet
    packages/webnet-v2.0.1/src/: webnet.c wn_mimetype.c wn_module.c wn_request.c wn_session.c wn_utils.c
    packages/webnet-v2.0.1/module/: wn_module_alias.c wn_module_asp.c wn_module_auth.c wn_module_cgi.c wn_module_dav.c wn_module_index.c wn_module_log.c wn_module_ssi.c wn_module_upload.c
    packages/webnet-v2.0.1/samples/: wn_sample.c wn_sample_upload.c
