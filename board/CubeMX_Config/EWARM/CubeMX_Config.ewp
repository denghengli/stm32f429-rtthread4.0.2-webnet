# IAR project CubeMX_Config.ewp, settings and files
configuration CubeMX_Config (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: CubeMX_Config.hex
  ILINK.IlinkOutputFile: CubeMX_Config.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: CubeMX_Config.ipcf
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp TouchGFXHAL.cpp STM32TouchController.cpp STM32DMA.cpp OSWrappers.cpp TouchGFXGPIO.cpp app_touchgfx.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
