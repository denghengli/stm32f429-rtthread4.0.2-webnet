# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32F429xx
  c include: .;rt-thread\include;applications;.;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\drv_flash;board\CubeMX_Config\Src;board\CubeMX_Config\Middlewares\ST\touchgfx\framework\include;board\CubeMX_Config\Src\generated\fonts\include;board\CubeMX_Config\Src\generated\gui_generated\include;board\CubeMX_Config\Src\generated\images\include;board\CubeMX_Config\Src\generated\texts\include;board\CubeMX_Config\Src\gui\include;packages\fal-latest\inc;packages\netutils-v1.2.0\ntp;packages\network_samples-v0.3.0;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\net\lwip-2.0.2\src;rt-thread\components\net\lwip-2.0.2\src\include;rt-thread\components\net\lwip-2.0.2\src\include\ipv4;rt-thread\components\net\lwip-2.0.2\src\arch\include;rt-thread\components\net\lwip-2.0.2\src\include\netif;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\dfs_net\sys_select;rt-thread\components\net\sal_socket\include\socket\sys_socket;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;libraries\STM32F4xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/ports/: phy_reset.c spi_flash_init.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_soft_spi.c drv_eth.c drv_sdram.c drv_lcd_rgb.c drv_ltdc.c drv_touch.c drv_common.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group TouchGFX_app
    board/CubeMX_Config/Src/: touchgfx_sample.c OSWrappers-rtt.cpp STM32DMA.cpp STM32TouchController.cpp TouchGFXGPIO.cpp TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp TouchGFXHAL.cpp app_touchgfx.c
    board/CubeMX_Config/Middlewares/ST/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group TouchGFX_generated
    board/CubeMX_Config/Src/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp FontCache.cpp Font_DENGB_TTF_20_4bpp_0.cpp Font_DENGB_TTF_20_4bpp_10.cpp Font_DENGB_TTF_20_4bpp_12.cpp Font_DENGB_TTF_20_4bpp_14.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp GeneratedFont.cpp Kerning_DENGB_TTF_20_4bpp.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_DENGB_TTF_20_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp
    board/CubeMX_Config/Src/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    board/CubeMX_Config/Src/generated/gui_generated/src/screen1_screen/: screen1ViewBase.cpp
    board/CubeMX_Config/Src/generated/gui_generated/src/screen2_screen/: Screen2ViewBase.cpp
    board/CubeMX_Config/Src/generated/gui_generated/src/screen3_screen/: Screen3ViewBase.cpp
    board/CubeMX_Config/Src/generated/images/src/: BitmapDatabase.cpp image_lightbulb_1.cpp image_lightbulb_2.cpp image_shou.cpp image_xuanzhong.cpp
    board/CubeMX_Config/Src/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFX_resource
    board/CubeMX_Config/Src/generated/images/src/__designer/: image_Blue_Buttons_Round_Edge_small.cpp image_Blue_Buttons_Round_Edge_small_pressed.cpp
  group TouchGFX_gui
    board/CubeMX_Config/Src/gui/src/common/: FrontendApplication.cpp
    board/CubeMX_Config/Src/gui/src/model/: Model.cpp
    board/CubeMX_Config/Src/gui/src/screen1_screen/: screen1Presenter.cpp screen1View.cpp
    board/CubeMX_Config/Src/gui/src/screen2_screen/: Screen2Presenter.cpp Screen2View.cpp
    board/CubeMX_Config/Src/gui/src/screen3_screen/: Screen3Presenter.cpp Screen3View.cpp
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-latest/samples/porting/: fal_flash_sfud_port.c
  group NetUtils
    packages/netutils-v1.2.0/ntp/: ntp.c
  group network-samples
    packages/network_samples-v0.3.0/: tcpclient_sample.c tcpserver_sample.c udpclient_sample.c udpserver_sample.c tcpclient_select_sample.c httpclient_sample.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group STM32_HAL
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_eth.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_ltdc.c
